# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Key.c Key.h nixie.c nixie.h Timer0.c Timer0.h
    ../../21.AT24C02初学/project/: Delay.h Delay.c
